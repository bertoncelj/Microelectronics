Vaja5

*includamo tranzistor
    .include models.inc

    *AC analiza

    *upornosti
    r_r1    1   2   r=146.6k
    r_r2    2   0   r=75.9k

    r_re    6   0   r=1k
    r_rc    1   4   r=1.4k

    r_rl    7   0   r=10k

    *kapacitiovnosti
    c_c1    8    2    c=100u
    c_c2    4    7    c=100u
    c_ce    6    0    c=100u

    *napajalniki
    vcc      1   0   dc=10
    v_vin    8   0   dc=0   sin(0,0.005,2k) acmag=1

    *viri nadomestni za merjenje toka
    v_icq1    4  10  dc=0
    v_icq2    4  9   dc=0
    v_ieq1    5  11  dc=0

    * m_imeTran (c b e) imeModela parametri
    q_q1    10 2 5   T2N2222
    q_q2    9 11 6   T2N2222

    .control

    destroy all

    echo _________VAJA4__________
    echo
    echo
    echo .........NALOGA_2.........

    *naredi DC analizo
    op

    *nastavimo vektorje ki jih iscemo
    let icq1  = i(v_icq1)
    let icq2  = i(v_icq2)
    let veq1  = v(10,5)
    let veq2  = v(9,6)

    *izpisemo vektroje
     print icq1, icq2, veq1, veq2

    echo
    echo .........NALOGA_3................

    echo ----------------------Napetostno, Tokovno ojacanje-----------------------------

	tran 1u 5m

	*napetostno ojacanje
		let vout=v(7)
		let vin=v(8)

    	let vout_pp=max(vout)-min(vout)
		let vin_pp=max(vin)-min(vin)

		let Av = vout_pp/vin_pp

	*tokovno ojacanje
		let iin = i(v_vin)
		let iout = vout/@r_rl[r]

		let iout_pp=max(iout) - min(iout)
		let iin_pp=max(iin) - min(iin)

		let Ai=iout_pp/iin_pp

	*izpise ojacanje
	print  Ai Av

 	echo
    echo .........NALOGA_4................

    echo ----------------------Malosignalna izmenicna analiza-----------------------------

    *malosignalna izmenicna analiza => potrebuje vsaj en acmag vir
    *sytaxa:
        *ac tip_skale st_tock fstart fstop
    *Kva naredi spice?:condenzatorje in tuljave nadomesti z kompleksorji

    ac  dec   10   1   100meg

    let vout=v(7)
	let vin=v(8)
	av=vout/vin
    *aplitudni spekter
    let av_db=db(av)

    *phase spector
    let av_ph=ph(av)

    plot av_db xlabel 'f' ylabel 'Av[dB]'
    plot av_ph xlabel 'f' ylabel 'Phase'

    *fl in fh se odcita iz grafa -> 3dB dy in pugledas kok kaze dx

    *fh = 3*10^5
    *fl = 4*10^3
    *izpis av za AC izmenicni signal
    *print av

    echo
    echo .........NALOGA_5................
    echo ----------------------Vhodna impedanca-----------------------------

    let vin_z = v(8)
	let iin_z = i(v_vin)

	let z_in = vin_z/iin_z
	let z_in_abs = abs(z_in)

	plot z_in_abs
	*vrednost preberes z grafa dol pri 5kHz
    *z_in = 4.45*10^4 -> prebrana iz grafa dol
    .endc
.end
