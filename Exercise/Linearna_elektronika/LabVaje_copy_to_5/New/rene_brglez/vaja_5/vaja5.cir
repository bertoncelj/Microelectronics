vaja 5

.include models.inc

r_r1	2 3	r=143.7k
r_r2	2 0	r=76.7k
r_rc	3 4	r=1463
r_re	6 0	r=1027
r_rl	8 0	r=10k

c_c1	2 1	c=100u
c_c2	4 8	c=100u
c_c3	6 0	c=100u

v_vcc	3 0	dc=10
v_vin	1 0	dc=0	sin(0,0.005,5k) acmag=1

v_vmer1	4 t1	dc=0
v_vmer2	4 t2	dc=0

q1 t1 2 5 T2N2222
q2 t2 5 6 T2N2222

 .control

    destroy all

    echo ##################### Vaja 5 ############################

    echo ---------------------- OP1 -----------------------------
    *Delovna tocka
    op

	let Vceq1=v(t1,5)
	let Vceq2=v(t2,6)

	let Icq1=i(v_vmer1)
	let Icq2=i(v_vmer2)

    print Vceq1 Icq1 Vceq2 Icq2

 	echo ---------------------- Transientna analiza -----------------------------

	tran 1u 5m

	let vout=v(8)
	let vin=v(1)

	let iin=i(v_vin)
	let iout=vout/@r_rl[r]

	let vout_pp=max(vout)-min(vout)
	let vin_pp=max(vin)-min(vin)

	let iout_pp=max(iout)-min(iout)
	let iin_pp=max(iin)-min(iin)

	let Av=vout_pp/vin_pp
	let Ai=iout_pp/iin_pp

	print Av Ai

	plot vout vin v(5)

	echo ---------------------- Malosignalna analiza -----------------------------

	ac dec 10 1 10meg

	let vout=v(8)
	let vin=v(1)
	let av=vout/vin
	let av_abs=abs(av)
	let av_db=db(av)

	plot Av_abs

	plot av_db

	let c=0
	* cursor ime_cursorja smer vektor vrednost
	cursor c right av_db {max(av_db)-3}
	let fl = abs(frequency[%c])
	print fl

	let c= c+1
	cursor c right av_db {max(av_db)-3}
	let fh = abs(frequency[%c])
	print fh

	let c1=0
	cursor c1 right abs(frequency) {5k}
	let av_5k = av_db[%c1]
	print av_5k

	let vin = v(1)
	let iin = i(v_vin)

	let zin = vin/iin
	let zin_abs = abs(zin)

	plot zin_abs

	let c2=0
	cursor c2 right abs(frequency) {5k}
	let zin_abs_5k = zin_abs[%c2]
	print zin_abs_5k

    .endc

.end
